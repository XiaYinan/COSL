# Keil uVision project TMS570ls3137.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TMS570LS3137 Texas Instruments
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x002FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") EBIG
  output: TMS570ls3137 +hex
  c flags: Optim=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x300000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\source\sys_link.cmd
  group source
    ./source/: sys_main.c adc.c esm.c gio.c i2c.c lin.c mibspi.c Notification.c pinmux.c sci.c het.c spi.c sys_dma.c sys_pcr.c sys_phantom.c sys_pmm.c sys_selftest.c sys_startup.c sys_vim.c system.c dabort.asm sys_core.asm sys_intvecs.asm sys_mpu.asm sys_pmu.asm
  group include
    ./include/: adc.h can.h crc.h dcc.h Device_header.h Device_TMS570LS31.h Device_types.h dmm.h emac.h emif.h esm.h fee_interface.h gio.h hal_stdtypes.h het.h htu.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h i2c.h lin.h mdio.h MemMap.h mibspi.h phy_dp83640.h pinmux.h pom.h reg_adc.h reg_can.h reg_crc.h reg_dcc.h reg_dma.h reg_dmm.h reg_efc.h reg_emif.h reg_esm.h reg_flash.h reg_gio.h reg_het.h reg_htu.h reg_i2c.h reg_lin.h reg_mibspi.h reg_pbist.h reg_pcr.h reg_pinmux.h reg_pmm.h reg_pom.h reg_rti.h reg_rtp.h reg_sci.h reg_spi.h reg_stc.h reg_system.h reg_tcram.h reg_vim.h rti.h rtp.h sci.h spi.h std_nhet.h sys_common.h sys_core.h sys_dma.h sys_mpu.h sys_pcr.h sys_pmm.h sys_pmu.h sys_selftest.h sys_vim.h system.h ti_fee.h ti_fee_cfg.h ti_fee_types.h
